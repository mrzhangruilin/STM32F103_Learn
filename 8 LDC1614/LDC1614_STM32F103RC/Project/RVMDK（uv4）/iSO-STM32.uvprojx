# Keil uVision project iSO-STM32.uvprojx, settings and files
target USART1（interrupt） (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\flash;..\..\User\systick;..\..\User\TimBase;..\..\User\adc;..\..\User\motor;..\..\User\Redray;..\..\User\IIC;..\..\User\LDC1314;..\..\User;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c
  group USER
    ../../User/: include.h stm32f10x_conf.h main.c stm32f10x_it.c
    ../../User/usart/: bsp_usart1.c
    ../../User/systick/: bsp_SysTick.c
    ../../User/TimBase/: bsp_TiMbase.c
    ../../User/IIC/: I2C.c
    ../../User/LDC1314/: LDC1314.c
  group Document
    ../../Doc/: Readme.txt
software components: CMSIS:CORE 5.0.1
