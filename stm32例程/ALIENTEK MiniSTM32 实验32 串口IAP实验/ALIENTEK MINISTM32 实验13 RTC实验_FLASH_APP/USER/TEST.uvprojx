# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  AfterMake: D:\MDK5.14\ARM\ARMCC\bin\fromelf.exe  --bin -o  ..\OBJ\TEST.bin ..\OBJ\TEST.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USMART;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\RTC
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/RTC/: rtc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: README.TXT
